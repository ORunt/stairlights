# Keil uVision project stairlights.uvprojx, settings and files
target stairlights (6160000::V6.16::ARMCLANG)
  device: STM32F030C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stairlights +hex
  BeforeMake: .\python\generate_lookup_table.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\src;.\inc;.\drivers\vl53l0x\core\src;.\drivers\vl53l0x\core\inc;.\drivers\vl53l0x\platform
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c stairlight_functions.c
  group periphials
    ./src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32_i2c_high_level.c stm32f0xx_i2c.c stm32f0xx_adc.c
  group inc
    ./inc/: stm32f0xx.h stm32f0xx_exti.h stm32f0xx_gpio.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_tim.h stm32f0xx_usart.h system_stm32f0xx.h stm32f0xx_conf.h stm32f0xx_misc.h stm32f0xx_syscfg.h main.h stairlight_functions.h graph_lookup_table.h stm32_i2c_high_level.h stm32f0xx_i2c.h stm32f0xx_adc.h
    ./drivers/vl53l0x/platform/: vl53l0x.h vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_types.h
    ./drivers/vl53l0x/core/inc/: vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h
  group drivers
    ./drivers/vl53l0x/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./drivers/vl53l0x/platform/: vl53l0x.c vl53l0x_platform.c vl53l0x_platform_log.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
